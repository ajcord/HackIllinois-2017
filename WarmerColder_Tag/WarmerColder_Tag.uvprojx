# Keil uVision project WarmerColder_Tag.uvprojx, settings and files
target WarmerColder_Tag (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.pdsc
  output: WarmerColder_Tag
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_SEEED_TINY_BLE -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTARGET_MCU_NRF51_16K_S130 -D__ASSERT_MSG -DTARGET_NRF51822 --no_rtti -Otime -DDEVICE_PORTINOUT=1 -c -DTARGET_NORDIC -O3 -DTARGET_MCU_NRF51822 -DDEVICE_PORTOUT=1 -DTARGET_RELEASE --split_sections -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M0 -DTARGET_MCU_NORDIC_16K -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -D__CORTEX_M0 -DNRF51 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DTARGET_MCU_NRF51 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DMBED_BUILD_TIMESTAMP=1488079184.51 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_MCU_NRF51_16K
  c include: .; nRF51822; nRF51822/source; nRF51822/source/common; nRF51822/source/nordic-sdk; nRF51822/source/nordic-sdk/components; nRF51822/source/nordic-sdk/components/device; nRF51822/source/nordic-sdk/components/drivers_nrf; nRF51822/source/nordic-sdk/components/drivers_nrf/hal; nRF51822/source/nordic-sdk/components/drivers_nrf/ble_flash; nRF51822/source/nordic-sdk/components/drivers_nrf/pstorage; nRF51822/source/nordic-sdk/components/drivers_nrf/pstorage/config; nRF51822/source/nordic-sdk/components/libraries; nRF51822/source/nordic-sdk/components/libraries/bootloader_dfu; nRF51822/source/nordic-sdk/components/libraries/bootloader_dfu/hci_transport; nRF51822/source/nordic-sdk/components/libraries/crc16; nRF51822/source/nordic-sdk/components/libraries/hci; nRF51822/source/nordic-sdk/components/libraries/scheduler; nRF51822/source/nordic-sdk/components/libraries/util; nRF51822/source/nordic-sdk/components/ble; nRF51822/source/nordic-sdk/components/ble/device_manager; nRF51822/source/nordic-sdk/components/ble/device_manager/config; nRF51822/source/nordic-sdk/components/ble/common; nRF51822/source/nordic-sdk/components/ble/ble_services; nRF51822/source/nordic-sdk/components/ble/ble_services/ble_dfu; nRF51822/source/nordic-sdk/components/ble/ble_radio_notification; nRF51822/source/nordic-sdk/components/softdevice; nRF51822/source/nordic-sdk/components/softdevice/common; nRF51822/source/nordic-sdk/components/softdevice/common/softdevice_handler; nRF51822/source/nordic-sdk/components/softdevice/s130; nRF51822/source/nordic-sdk/components/softdevice/s130/headers; nRF51822/source/btle; nRF51822/source/btle/custom; nRF51822/bootloader; BLE_API; BLE_API/source; BLE_API/source/services; BLE_API/ble; BLE_API/ble/services; mbed/.; mbed/TARGET_SEEED_TINY_BLE; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_8_0_0; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s130_nrf51822_1_0_0; mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_SEEED_TINY_BLE; mbed/TARGET_SEEED_TINY_BLE/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DTARGET_MCU_NRF51_16K,-DNRF51,-DTARGET_MCU_NRF51_16K_S130,-DTARGET_NRF51822,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTARGET_MCU_NORDIC_16K
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_SEEED_TINY_BLE/TOOLCHAIN_ARM_STD/nRF51822.sct
  group 
    ./: mbed_config.h color.h main.cpp color.cpp
  group ble_flash
    nRF51822/source/nordic-sdk/components/drivers_nrf/ble_flash/: ble_flash.h ble_flash.c
  group services
    BLE_API/ble/services/: HealthThermometerService.h EnvironmentalService.h URIBeaconConfigService.h DeviceInformationService.h iBeacon.h HeartRateService.h EddystoneService.h EddystoneConfigService.h DFUService.h UARTService.h LinkLossService.h BatteryService.h
    BLE_API/source/services/: UARTService.cpp DFUService.cpp URIBeaconConfigService.cpp
  group btle
    nRF51822/source/btle/: btle_security.h btle_advertising.h btle_discovery.h btle_gap.h btle.h btle_gap.cpp btle_advertising.cpp btle_discovery.cpp btle.cpp btle_security.cpp
  group hal
    nRF51822/source/nordic-sdk/components/drivers_nrf/hal/: nrf_ecb.h nrf_wdt.h nrf_gpio.h nrf_nvmc.h nrf_temp.h nrf_gpiote.h nrf_delay.c nrf_nvmc.c nrf_ecb.c
  group TARGET_SEEED_TINY_BLE
    mbed/TARGET_SEEED_TINY_BLE/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h compiler_abstraction.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h nrf.h nrf51.h nrf51_bitfields.h nrf_delay.h system_nrf51.h
    mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_SEEED_TINY_BLE/: PinNames.h device.h
  group hci_transport
    nRF51822/source/nordic-sdk/components/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h
  group custom
    nRF51822/source/btle/custom/: custom_helper.h custom_helper.cpp
  group source
    nRF51822/source/: projectconfig.h nRF5xServiceDiscovery.h nRF5xDiscoveredCharacteristic.h nRF5xSecurityManager.h nRF5xGattServer.h nRF5xn.h nRF5xGattClient.h nRF5xGap.h nRF5xSecurityManager.cpp nRF5xGattClient.cpp nRF5xServiceDiscovery.cpp nRF5xDiscoveredCharacteristic.cpp nRF5xn.cpp nRF5xGap.cpp nRF5xGattServer.cpp
    BLE_API/source/: GapScanningParams.cpp DiscoveredCharacteristic.cpp BLE.cpp
  group ble
    BLE_API/ble/: GapAdvertisingData.h UUID.h Gap.h ServiceDiscovery.h SafeBool.h GapScanningParams.h DiscoveredCharacteristic.h BLEInstanceBase.h GattCharacteristic.h GattServerEvents.h GattClient.h CallChainOfFunctionPointersWithContext.h GapAdvertisingParams.h SecurityManager.h BLE.h FunctionPointerWithContext.h GattAttribute.h GattServer.h GattCallbackParamTypes.h GapEvents.h blecommon.h GattService.h DiscoveredService.h
  group hci
    nRF51822/source/nordic-sdk/components/libraries/hci/: hci_mem_pool.h hci_mem_pool.c
  group config
    nRF51822/source/nordic-sdk/components/drivers_nrf/pstorage/config/: pstorage_platform.h
    nRF51822/source/nordic-sdk/components/ble/device_manager/config/: device_manager_cnfg.h
  group crc16
    mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16/: crc16.h
    nRF51822/source/nordic-sdk/components/libraries/crc16/: crc16.c
  group util
    nRF51822/source/nordic-sdk/components/libraries/util/: app_util_platform.h sdk_errors.h sdk_os.h nordic_common.h nrf_assert.h common.h sdk_common.h app_error.c app_util_platform.c nrf_assert.c
    mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util/: app_error.h app_util.h
  group pstorage
    nRF51822/source/nordic-sdk/components/drivers_nrf/pstorage/: pstorage.h pstorage.c
  group scheduler
    mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler/: app_scheduler.h
    nRF51822/source/nordic-sdk/components/libraries/scheduler/: app_scheduler.c
  group device
    nRF51822/source/nordic-sdk/components/device/: compiler_abstraction.h nrf51_deprecated.h nrf51.h nrf51_bitfields.h nrf.h
  group device_manager
    nRF51822/source/nordic-sdk/components/ble/device_manager/: device_manager.h device_manager_peripheral.c
  group TARGET_MCU_NRF51822
    mbed/TARGET_SEEED_TINY_BLE/TARGET_NORDIC/TARGET_MCU_NRF51822/: PeripheralNames.h PortNames.h gpio_object.h objects.h twi_config.h twi_master.h
  group bootloader_dfu
    nRF51822/source/nordic-sdk/components/libraries/bootloader_dfu/: bootloader.h dfu_init.h dfu_app_handler.h bootloader_util.h dfu_ble_svc.h dfu.h dfu_ble_svc_internal.h bootloader_types.h dfu_bank_internal.h dfu_types.h dfu_transport.h dfu_init_template.c dfu_app_handler.c bootloader_util.c
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_SEEED_TINY_BLE/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o retarget.o startup_nRF51822.o sys.o system_nrf51.o mbed.ar
  group headers
    nRF51822/source/nordic-sdk/components/softdevice/s130/headers/: ble_gattc.h nrf_soc.h ble_ranges.h nrf_sdm.h nrf_svc.h nrf_error.h ble_l2cap.h nrf_error_sdm.h nrf_mbr.h ble_gap.h ble_types.h ble_gatts.h ble_gatt.h ble.h ble_hci.h nrf_error_soc.h ble_err.h softdevice_assert.h
  group common
    nRF51822/source/common/: ble_error.h binary.h ansi_escape.h assertion.h compiler.h common.h
    nRF51822/source/nordic-sdk/components/ble/common/: ble_sensor_location.h ble_advdata_parser.h ble_srv_common.h ble_conn_params.h ble_date_time.h ble_advdata.h ble_advdata.c ble_advdata_parser.c ble_srv_common.c ble_conn_params.cpp
  group ble_dfu
    nRF51822/source/nordic-sdk/components/ble/ble_services/ble_dfu/: ble_dfu.h ble_dfu.c
  group softdevice_handler
    nRF51822/source/nordic-sdk/components/softdevice/common/softdevice_handler/: ant_stack_handler_types.h softdevice_handler.h ble_stack_handler_types.h softdevice_handler_appsh.h softdevice_handler.c softdevice_handler_appsh.c
  group ble_radio_notification
    nRF51822/source/nordic-sdk/components/ble/ble_radio_notification/: ble_radio_notification.h ble_radio_notification.c
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CThunk.h CallChain.h CircularBuffer.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h Transaction.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h toolchain.h us_ticker_api.h wait_api.h
